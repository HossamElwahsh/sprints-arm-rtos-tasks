# Keil uVision project RTOSDemo.uvproj, settings and files
target RTOSDemo_ARM (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTOSDemo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM7_LPC21xx_KEIL_RVDS
  c include: .;..\..\Source\portable\RVDS\ARM7_LPC21xx;..\Common\include;..\..\Source\include
  asm include: ..\..\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group FreeRTOS
    ../FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: portASM.s port.c
    ../FreeRTOS/Source/: tasks.c list.c queue.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Other
    ./: Startup.s
    ./ParTest/: ParTest.c
    ./serial/: serialISR.s
  group Task_Files
    ./lib/: bit_math.h std.h
    ./src/: GPIO.c GPIO_cfg.c main.c serial.c
target RTOSDemo_THUMB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2129 NXP (founded by Philips)
  cpu: as above
  output: RTOSDemo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: .;..\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;.\src;.\headers;.\lib;..\FreeRTOS\Demo\Common\include;..\FreeRTOS\Source\include
  asm include: ..\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
